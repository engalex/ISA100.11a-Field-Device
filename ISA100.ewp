# IAR project ISA100.ewp, settings and files
configuration BackboneTransceiver (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: MC1322x Freescale MC1322x
  ICCARM.CCDefines: BACKBONE_SUPPORT; DEVICE_TYPE=DEV_TYPE_MC13225; PLATFORM=PLATFORM_DEVELOPMENT; DEBUG_RESET_REASON
  ICCARM.CCIncludePath2: typedef.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Transceiver_v01_00_xx.hex
  postbuild: "$TOOLKIT_DIR$\bin\objcopy.exe" --output-target=binary "$TARGET_BPATH$.out" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: Transceiver_v01_00_xx.out
  ILINK.IlinkIcfFile: MC1322x-RAM-ROM.icf
  ILINK.IlinkProgramEntryLabel: _start_vector_
configuration VN210_RoutingFullAPI_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEVICE_TYPE=DEV_TYPE_MC13225; _UAP_TYPE=UAP_TYPE_ISA100_API; ROUTING_SUPPORT; SPI1_MODE=1; UART2_MODE=0; PLATFORM=PLATFORM_VN210; DEBUG_RESET_REASON
  AARM.ADefines: USE_INTERRUPTS; NO_USE_EXCEPTIONS
  OBJCOPY.OOCOutputFile: VN210_RoutingFullAPI_SPI_v01_00_xx.hex
  ILINK.IlinkOutputFile: VN210_RoutingFullAPI_SPI_v01_00_xx.out
configuration VN210_RoutingFullAPI_UART (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEVICE_TYPE=DEV_TYPE_MC13225; _UAP_TYPE=UAP_TYPE_ISA100_API; ROUTING_SUPPORT; SPI1_MODE=0; UART2_MODE=1; PLATFORM=PLATFORM_VN210; DEBUG_RESET_REASON
  AARM.ADefines: USE_INTERRUPTS; NO_USE_EXCEPTIONS
  OBJCOPY.OOCOutputFile: VN210_RoutingFullAPI_UART_v01_00_xx.hex
  ILINK.IlinkOutputFile: VN210_RoutingFullAPI_UART_v01_00_xx.out
configuration VN210_RoutingFullAPI_SPI_ExtWakeup (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEVICE_TYPE=DEV_TYPE_MC13225; _UAP_TYPE=UAP_TYPE_ISA100_API; ROUTING_SUPPORT; SPI1_MODE=1; UART2_MODE=0; PLATFORM=PLATFORM_VN210; WAKEUP_ON_EXT_PIN; DEBUG_RESET_REASON
  AARM.ADefines: USE_INTERRUPTS; NO_USE_EXCEPTIONS
  OBJCOPY.OOCOutputFile: VN210_RoutingFullAPI_SPI_ExtWakeup_v01_00_xx.hex
  ILINK.IlinkOutputFile: VN210_RoutingFullAPI_SPI_ExtWakeup_v01_00_xx.out
configuration VN210_RoutingFullAPI_UART_ExtWakeup (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEVICE_TYPE=DEV_TYPE_MC13225; _UAP_TYPE=UAP_TYPE_ISA100_API; ROUTING_SUPPORT; SPI1_MODE=0; UART2_MODE=1; PLATFORM=PLATFORM_VN210; WAKEUP_ON_EXT_PIN; DEBUG_RESET_REASON
  AARM.ADefines: USE_INTERRUPTS; NO_USE_EXCEPTIONS
  OBJCOPY.OOCOutputFile: VN210_RoutingFullAPI_UART_ExtWakeup_v01_00_xx.hex
  ILINK.IlinkOutputFile: VN210_RoutingFullAPI_UART_ExtWakeup_v01_00_xx.out
  group (top)
    ./: Init-IAR.S
  group arch_sources
    source_files/: asm.c crm.c digitals.c global.c itc.c maca.c main.c MC1322x.c spi.c spif_interface.c timers.c uart1.c uart2.c
  group arch_sources/header
    source_files/: asm.h crm.h digitals.h global.h itc.h maca.h MC1322x.h spif_interface.h system.h timers.h typedef.h uart1.h uart2.h
  group CommonAPI
    source_files/CommonAPI/: Common_API.c DAQ_Comm.c
  group ISA100_sources
    source_files/ISA100/: aslde.c aslsrvc.c dlde.c dlme.c dlmo_utils.c dmap.c dmap_armo.c dmap_co.c dmap_dlmo.c dmap_dmo.c dmap_dpo.c dmap_udo.c dmap_utils.c mlde.c mlsm.c nlde.c nlme.c phy.c provision.c slme.c tlde.c tlme.c uap.c uart_link.c
  group lib
    libs/: LLC.a MC1322x.a

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ISA100.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All_Configs</name>
      <member>
        <project>ISA100</project>
        <configuration>BackboneDevice_Debug</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GEBackboneDevice</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GERoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GERoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPNonRoutingSimpleAPI_SPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPNonRoutingSimpleAPI_UART</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPRoutingSimpleAPI_SPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPRoutingSimpleAPI_UART</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPNonRoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPNonRoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPRoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPRoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>Reset provion info</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>YK_BackboneRouter</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>YKRoutingFullAPI_UART</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>YKRoutingSimpleAPI_UART</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>BBR+NonRouting+Routing</name>
      <member>
        <project>ISA100</project>
        <configuration>BackboneDevice_Debug</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPNonRoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPNonRoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPRoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>LPRoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GEBackboneDevice</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GERoutingIsaAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>GERoutingSimpleAPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPNonRoutingSimpleAPI_SPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPNonRoutingSimpleAPI_UART</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPRoutingSimpleAPI_SPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>IK_LPRoutingSimpleAPI_UART</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>ProvisioningDevice_Debug</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>Reset provion info</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>YKRoutingSimpleAPI_SPI</configuration>
      </member>
      <member>
        <project>ISA100</project>
        <configuration>YKRoutingSimpleAPI_UART</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All Libraries</name>
      <member>
        <project>ISA100_Lib</project>
        <configuration>BackboneDevice_Debug</configuration>
      </member>
      <member>
        <project>ISA100_Lib</project>
        <configuration>NonRoutingDevice_Debug</configuration>
      </member>
      <member>
        <project>ISA100_Lib</project>
        <configuration>RoutingDevice_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


